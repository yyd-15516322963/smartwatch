# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\adc;..\HARDWARE\mht11;..\HARDWARE\oled;..\HARDWARE\rtc;..\HARDWARE\tft;..\FONT;..\image;..\HARDWARE\key;..\HARDWARE\touch;..\HARDWARE\max301;..\HARDWARE\mpu6050;..\HARDWARE\ble
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/mht11/: mht11.c
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/tft/: tft.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/touch/: touch.c
    ../HARDWARE/Max301/: algorithm.c i2c.c max30102.c
    ../HARDWARE/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c mpu6050_i2c.c
    ../HARDWARE/ble/: ble.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dma2d.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_dma.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
  group font
    ../FONT/: FontDotMatrix16.c FontDotMatrix32.c FontDotMatrix80.c
  group image
    ../image/: battery.c camera.c date.c faceid.c fail.c humi.c light.c lock.c pulse.c rfid.c success.c temp.c time.c touchid.c unlock.c victory.c warning.c wifi.c blueos.c
